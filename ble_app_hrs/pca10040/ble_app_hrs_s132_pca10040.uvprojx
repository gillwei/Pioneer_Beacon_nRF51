# Keil uVision project ble_app_hrs_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52_PAN_12 S132 SWI_DISABLE0 NRF52 SOFTDEVICE_PRESENT NRF_LOG_USES_UART=1 ENABLE_DEBUG_LOG_SUPPORT DM_DISABLE_LOGS CONFIG_NFCT_PINS_AS_GPIOS DFBD_NNANN_PN0R_V11
  c misc: --c99
  c include: ..\APP_config;..\config\ble_app_hrs_s132_pca10040;..\config;..\..\components\ble\ble_advertising;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\common;..\..\components\ble\device_manager;..\..\components\drivers_ext\segger_rtt;..\..\components\drivers_nrf\common;..\..\components\drivers_nrf\config;..\..\components\drivers_nrf\delay;..\..\components\drivers_nrf\gpiote;..\..\components\drivers_nrf\hal;..\..\components\drivers_nrf\pstorage;..\..\components\drivers_nrf\uart;..\..\components\libraries\button;..\..\components\libraries\fifo;..\..\components\libraries\sensorsim;..\..\components\libraries\timer;..\..\components\libraries\trace;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\softdevice\common\softdevice_handler;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\components\toolchain;..\..\bsp;..\int_flash;..\ble_pbs;..\..\components\drivers_nrf\ppi;..\..\components\drivers_nrf\saadc;..\..\components\drivers_nrf\timer;..\..\components\drivers_nrf\spi_master;..\..\components\libraries\util;..\..\components\drivers_nrf\saadc
  asm define: BLE_STACK_SUPPORT_REQD NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 S132 SWI_DISABLE0 NRF52 SOFTDEVICE_PRESENT NRF_LOG_USES_UART=1
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x45000
  memory RVCT9: RAM 0x20001f00 size 0xfa00
  group Application
    ../: main.c
    ../ble_pbs/: ble_pbs.c
    ../APP_config/: int_flash.c button_led.c event_detection.c lis2dh12.c spi_flash_MXIC.c read_adc.c
  group Board Support
    ../../bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../components/drivers_nrf/delay/: nrf_delay.c
    ../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../components/drivers_nrf/pstorage/: pstorage.c
    ../../components/libraries/uart/: app_uart_fifo.c
    ../../components/drivers_nrf/hal/: nrf_saadc.c
    ../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
  group nRF_Libraries
    ../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/sensorsim/: sensorsim.c
    ../../components/libraries/trace/: app_trace.c
    ../../components/libraries/uart/: retarget.c
    ../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c app_util_platform.c
    ../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../components/softdevice/s132/doc/: s132_nrf52_2.0.0-7.alpha_licence_agreement.txt
target flash_s132_nrf52_2.0.0-7.alpha_softdevice (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: as above
  output: s132_nrf52_2.0.0-7.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF52
  c misc: --c99
  c include: ..\..\..\config\ble_app_hrs_s132_pca10040;..\..\..\config;..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.1
